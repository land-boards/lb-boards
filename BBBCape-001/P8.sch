File: BBBCape-001/P8.sch (KiCad schematic (older format))
At the start: 2 parts, among them P3 CONN_23X2, U1 BEAGLEBONE

Commit message: bbb gvs 5x
Parts:
- removed P3: CONN_23X2, symbol CONN_23X2
